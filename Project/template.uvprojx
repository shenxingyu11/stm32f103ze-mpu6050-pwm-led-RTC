# Keil uVision project template.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\inc;..\Libraries\CMSIS;..\Project;..\User\usart;..\User\beep;..\User\delay;..\User\dht11;..\User\i2c;..\User\Key;..\User\Led;..\User\mpu6050;..\User\rtc;..\User\sys;..\User\SysTick;..\User\usart;..\User\lcd;..\User\font;..\User\breathinglight
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/SATRTUP/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group FWLB
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./: stm32f10x_it.c main.c
    ../User/beep/: beep.c
    ../User/delay/: delay.c
    ../User/dht11/: bsp_dht11.c
    ../User/i2c/: bsp_i2c.c
    ../User/Key/: bsp_key.c
    ../User/mpu6050/: mpu6050.c
    ../User/rtc/: bsp_calendar.c bsp_date.c bsp_rtc.c
    ../User/sys/: sys.c
    ../User/SysTick/: bsp_SysTick.c
    ../User/usart/: bsp_usart.c
    ../User/font/: fonts.c
    ../User/lcd/: 9341_lcd.c
    ../User/breathinglight/: bsp_breathing.c
